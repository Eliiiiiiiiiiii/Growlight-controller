File: Controller.kicad_sch (KiCad schematic)
At the start: 9 parts, among them U101 TXS0102

Commit message: Add files via upload
Other:
- moved on the sheet: C101, C102, D101, R101, U101
